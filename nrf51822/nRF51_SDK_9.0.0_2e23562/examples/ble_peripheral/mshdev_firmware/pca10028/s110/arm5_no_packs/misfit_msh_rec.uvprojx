# Keil uVision project misfit_msh_rec.uvprojx, settings and files
target nrf51422_xxac_s110 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\libraries\bootloader_dfu;..\..\..\..\..\..\components\ble\device_manager;..\..\..\config;..\..\..\;..\..\..\..\..\..\components\drivers_nrf\rtc
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x40000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Application
    ../../../: main.c b_and_l.c spi_master2.c flash_manage.c app_timer.c LIS2DH.c g_sensor.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/libraries/timer/: app_timer_appsh.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group DFU
    ../../../../../../components/libraries/bootloader_dfu/: bootloader_util.c dfu_app_handler.c
    ../../../../../../components/ble/ble_services/ble_dfu/: ble_dfu.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
target flash_softdevice (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 4.1.0, Device:Startup 8.0.3
